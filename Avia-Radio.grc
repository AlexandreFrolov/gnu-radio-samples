options:
  parameters:
    author: Alexandre Frolov
    copyright: MIT
    description: Simple FM Radio
    generate_options: qt_gui
    id: Avia-Radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: 5e3
    audio_stop: 6e3
    chan_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.208e3
    decim: '10'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 120e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.400e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2.4e6
    fc: 128.125e6
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2.4e6
    fc: 128.125e6
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 128.1253e6
    gain0: '90'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
