options:
  parameters:
    author: Alexandre Frolov
    copyright: MIT
    description: Simple FM Radio
    generate_options: qt_gui
    id: FM-Radio-Regulator-Stereo
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Частота, Гц
    start: 88e6
    step: 0.1e6
    stop: 108e6
    value: 107e6
  states: {}
- name: mute_toggle
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'True'
    label: Вкл. звук
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: Усиление, dB
    type: int
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: volume_gain
  id: variable_qtgui_range
  parameters:
    label: Громкость
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '5'
    deemph_tau: '75e-6'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mute_toggle
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mute_toggle
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '10'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2.4e6
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2.4e6
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
